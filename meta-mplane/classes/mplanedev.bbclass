# Turn on various developer related flags in the Open M-Plane code.

inherit asan
inherit clang-analyze
inherit fbtests
